# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "C:\TI\mspm0_sdk_2_01_00_03\tools\keil\syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: C:\TI\mspm0_sdk_2_01_00_03\source\third_party\CMSIS\Core\Include;C:\TI\mspm0_sdk_2_01_00_03\source;..\Hardware;..\..\test_2;..\Application
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: C:\TI\mspm0_sdk_2_01_00_03\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c motion.c motion.h encoder.c encoder.h encoder_pid.c
    ./: startup_mspm0g350x_uvision.s
    ../Hardware/: board.c board.h oled.c oled.h mpu6050.c mpu6050.h imu.c imu.h tracking.c tracking.h
  group ApplicationNew Group
    ../Application/: line_follow.c line_follow.h task_manager.c task_manager.h task_1.c task_1.h task_2.c task_2.h angle_turn.c angle_turn.h task_3.c task_3.h
  group Hardware
    ../Hardware/: key.c key.h imu_uart_link.c imu_uart_link.h
